
SRC_URI = " \
        git://github.com/tci-development/kernel-tci-e04.git;user=git;protocol=ssh;branch=master \
"
SRCREV = "f54d3e2b59eee76810333302a82898b43c3cc837"
S = "${WORKDIR}/git"

LIC_FILES_CHKSUM = "file://COPYING;md5=d7810fab7487fb0aad327b76f1be7cd7"

